# Keil uVision project LCDPro.uvprojx, settings and files
target LCDPro (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCDPro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM;..\USER;..\STM32F10x_FWLIB\inc;..\FWLIB;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f103xe.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group STM32F10x_FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/gpioInit/: gpioInit.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/timerInit/: timerInit.c
    ../SYSTEM/uartTemp/: usartTemp.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/i2c/: i2cTemplate.c
    ../SYSTEM/spi/: spiTemplate.c
    ../SYSTEM/fsmc/: fsmc.c
  group BSP
    ../BSP/LCD/: lcd.c
